# Keil uVision project MX_02.uvprojx, settings and files
target MX_02 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L051R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: MX_02 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\uart_fault_noinit.sct
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User/Core
    ../Core/Src/: main.c usart.c spi.c tim.c gpio.c stm32l0xx_it.c stm32l0xx_hal_msp.c adc.c iwdg.c lptim.c
    ../Core/Inc/: config.h
  group User
    ../User/: ui.c New_Key.c ble_data.c LoraPro.c LoraTrace.c Sx126x_Driver.c Sleep.c flash.c Time_out.c soft_timer.c list.c L_B_ADC.c app_drv_fifo.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lptim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
target MX_02_AC6 (6210000::V6.21::.\ARMCLANG)
  device: STM32L051R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.3.1.0
  cpu: as above
  output: MX_02 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L051xx
  c misc: -Wno-invalid-utf8
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\uart_fault_noinit.sct
software components: CMSIS:CORE 6.1.0
